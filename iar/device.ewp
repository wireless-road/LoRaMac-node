# IAR project device.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071CB ST STM32L071CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32; DECAST_WATER; STM32L0; STM32L071CBTx; DEBUG; SX1276MB1LAS; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; REGION_RU864; PRODUCTION
  ICCARM.CCIncludePath2: E:\LoRaMac-node\loramac-node\src\apps\LoRaMac\classA\DecastWater\startup; E:\LoRaMac-node\loramac-node\src\boards\mcu\stm32; E:\LoRaMac-node\loramac-node\src\boards\mcu\stm32\cmsis; E:\LoRaMac-node\loramac-node\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc; E:\LoRaMac-node\loramac-node\src\mac; E:\LoRaMac-node\loramac-node\src\mac\region; E:\LoRaMac-node\loramac-node\src\peripherals; E:\LoRaMac-node\loramac-node\src\peripherals\soft-se; E:\LoRaMac-node\loramac-node\src\radio; E:\LoRaMac-node\loramac-node\src\system; E:\LoRaMac-node\loramac-node\src\m2m-fuota; E:\LoRaMac-node\loramac-node\src\m2m-fuota\Disk; E:\LoRaMac-node\loramac-node\src\m2m-fuota\common; E:\LoRaMac-node\loramac-node\src\m2m-fuota\common\LmHandler; E:\LoRaMac-node\loramac-node\src\m2m-fuota\common\LmHandler\packages; E:\LoRaMac-node\loramac-node\src\boards; E:\LoRaMac-node\loramac-node\src\boards\DecastWater; E:\LoRaMac-node\loramac-node\src\boards\DecastWater\cmsis; E:\LoRaMac-node\loramac-node\src\apps\LoRaMac\classA\DecastWater
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: device.bin
  ILINK.IlinkOutputFile: device.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/apps/LoRaMac/classA/DecastWater/: Commissioning.h
  group board
    ../src/boards/DecastWater/: adc-board.c ade7953.c ade7953.h ade7953_Regs.h board-config.h board.c delay-board.c eeprom-board.c gpio-board.c i2c-board.c lpm-board.c rtc-board.c spi-board.c sx1261mbxbas-board.c sx1262mbxcas-board.c sx1262mbxdas-board.c sx1272mb2das-board.c sx1276mb1las-board.c sx1276mb1mas-board.c uart-board.c
    ../src/boards/DecastWater/cmsis/: system_stm32l0xx.c
  group board/mcu/stm32
    ../src/boards/mcu/: utilities.c
  group board/mcu/stm32/HAL/inc
    ../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h stm32l0xx_hal_comp.h stm32l0xx_hal_comp_ex.h stm32l0xx_hal_conf_template.h stm32l0xx_hal_cortex.h stm32l0xx_hal_crc.h stm32l0xx_hal_crc_ex.h stm32l0xx_hal_cryp.h stm32l0xx_hal_cryp_ex.h stm32l0xx_hal_dac.h stm32l0xx_hal_dac_ex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_firewall.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_i2s.h stm32l0xx_hal_irda.h stm32l0xx_hal_irda_ex.h stm32l0xx_hal_iwdg.h stm32l0xx_hal_lcd.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pcd.h stm32l0xx_hal_pcd_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_rng.h stm32l0xx_hal_rtc.h stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_smartcard.h stm32l0xx_hal_smartcard_ex.h stm32l0xx_hal_smbus.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_tsc.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h stm32l0xx_hal_wwdg.h stm32l0xx_ll_adc.h stm32l0xx_ll_bus.h stm32l0xx_ll_comp.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crc.h stm32l0xx_ll_crs.h stm32l0xx_ll_dac.h stm32l0xx_ll_dma.h stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.h stm32l0xx_ll_i2c.h stm32l0xx_ll_iwdg.h stm32l0xx_ll_lptim.h stm32l0xx_ll_lpuart.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_rng.h stm32l0xx_ll_rtc.h stm32l0xx_ll_spi.h stm32l0xx_ll_system.h stm32l0xx_ll_tim.h stm32l0xx_ll_usart.h stm32l0xx_ll_utils.h stm32l0xx_ll_wwdg.h
  group board/mcu/stm32/HAL/inc/Legacy
    ../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group board/mcu/stm32/HAL/scr
    ../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group m2m-fuota
    ../src/m2m-fuota/: AppLoader.c AppLoader.h boot_main.c config.c config.h ConfigDefs.h crc.c crc.h FileLoader.c FileLoader.h flash.c flash.h LoRaWan.c LoRaWan.h main.c PlatformDefs.h Recovery.c Recovery.h Scheduler.c Scheduler.h Servises.c Servises.h syslog.c syslog.h TestApp.c TestApp.h Update.c Update.h version.c version.h xprintf.c xprintf.h
  group m2m-fuota/common
    ../src/m2m-fuota/common/: CayenneLpp.c CayenneLpp.h NvmCtxMgmt.c NvmCtxMgmt.h
  group m2m-fuota/common/LmHandler
    ../src/m2m-fuota/common/LmHandler/: LmHandler.c LmHandler.h LmHandlerTypes.h
  group m2m-fuota/common/LmHandler/packages
    ../src/m2m-fuota/common/LmHandler/packages/: FragDecoder.c FragDecoder.h LmhPackage.h LmhpClockSync.c LmhpClockSync.h LmhpCompliance.c LmhpCompliance.h LmhpFragmentation.c LmhpFragmentation.h LmhpRemoteMcastSetup.c LmhpRemoteMcastSetup.h
  group m2m-fuota/Disk
    ../src/m2m-fuota/Disk/: AT25SF041.c at25sf041.h FileFunc.c FileFunc.h LiteDisk.c LiteDisk.h LiteDiskDefs.c LiteDiskDefs.h mx25l.c mx25l.h mx25l_disk.c mx25l_disk.h
  group mac
    ../src/mac/: LoRaMac.c LoRaMac.h LoRaMacAdr.c LoRaMacAdr.h LoRaMacClassB.c LoRaMacClassB.h LoRaMacClassBConfig.h LoRaMacCommands.c LoRaMacCommands.h LoRaMacConfirmQueue.c LoRaMacConfirmQueue.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacHeaderTypes.h LoRaMacMessageTypes.h LoRaMacParser.c LoRaMacParser.h LoRaMacSerializer.c LoRaMacSerializer.h LoRaMacTest.h LoRaMacTypes.h secure-element.h
  group mac/region
    ../src/mac/region/: Region.c Region.h RegionAS923.c RegionAS923.h RegionAU915.c RegionAU915.h RegionCN470.c RegionCN470.h RegionCN779.c RegionCN779.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionIN865.c RegionIN865.h RegionKR920.c RegionKR920.h RegionRU864.c RegionRU864.h RegionUS915.c RegionUS915.h
  group peripherals
    ../src/peripherals/: gpio-ioe.c gpio-ioe.h mag3110.c mag3110.h mma8451.c mma8451.h nmea_gps.c nmea_gps.h nmea_gps_private.h
  group peripherals/soft-se
    ../src/peripherals/soft-se/: aes.c aes.h cmac.c cmac.h se-identity.h soft-se-hal.c soft-se-hal.h soft-se.c
  group radio
    ../src/radio/: radio.h
  group radio/sx1276
    ../src/radio/sx1276/: sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group startup
    ../src/apps/LoRaMac/classA/DecastWater/startup/: startup_stm32l071xx.s
  group system
    ../src/system/: adc.c adc.h delay.c delay.h eeprom.c eeprom.h fifo.c fifo.h gpio.c gpio.h gps.c gps.h i2c.c i2c.h nvmm.c nvmm.h serial.h spi.h systime.c systime.h timer.c timer.h uart.c uart.h
